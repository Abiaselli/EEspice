test V

V1 1 0 1
R1 1 0 1

.tran 0.1 1