test V

V1 1 0 0
R1 1 0 1

.tran 0.1 1